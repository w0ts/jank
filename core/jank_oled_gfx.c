/* SPDX-License-Identifier: GPL-3.0-only */
/* The OLED UI's drawing primitives and font (the emulator's px, rect, frame, xorCol, text, textR, textC, icon, FONT_SRC),
 * and the JavaScript number rules the screens' text depends on (Math.round, toFixed). */
#include "jank_oled_int.h"
#include <math.h>
#include <stdio.h>
#include <string.h>

double jo_round(double x)
{
    double r = floor(x);
    return x - r >= 0.5 ? r + 1.0 : r;          /* x - floor(x) is exact for every double */
}

/* n = |x| * 10^digits rounded half up, exactly: |x| = m * 2^e with m an integer of 53 bits */
static uint64_t scaled(double ax, int digits, int *ok)
{
    static const uint64_t P10[4] = {1, 10, 100, 1000};
    int e = 0, sh;
    double f;
    uint64_t m, big;
    *ok = isfinite(ax);
    if (!*ok || ax == 0.0)
        return 0;
    f = frexp(ax, &e);                           /* ax = f * 2^e, f in [0.5, 1) */
    m = (uint64_t)ldexp(f, 53);                  /* ax = m * 2^(e - 53), exactly */
    sh = 53 - e;
    big = m * P10[digits];                       /* < 2^63: m < 2^53, 10^3 < 2^10 */
    if (sh < 0) {                                /* ax >= 2^53: beyond any value the screens show */
        *ok = 0;
        return 0;
    }
    if (sh == 0)
        return big;
    if (sh > 63)                                /* ax < 2^-10: ax * 10^3 < 1, rounds to 0 */
        return ax * (double)P10[digits] >= 0.5 ? 1u : 0u;
    {
        uint64_t n = big >> sh, rem = big & ((1ull << sh) - 1u), half = 1ull << (sh - 1);
        return rem >= half ? n + 1u : n;
    }
}

void jo_fixed(double x, int digits, char *out, size_t cap)
{
    static const uint64_t P10[4] = {1, 10, 100, 1000};
    int ok;
    uint64_t n;
    if (digits < 0)
        digits = 0;
    if (digits > 3)
        digits = 3;
    n = scaled(fabs(x), digits, &ok);
    if (!ok) {                                   /* (beyond any value the screens show) */
        snprintf(out, cap, "%.*f", digits, x);
        return;
    }
    if (digits)
        snprintf(out, cap, "%s%llu.%0*llu", x < 0 ? "-" : "", (unsigned long long)(n / P10[digits]), digits,
                 (unsigned long long)(n % P10[digits]));
    else
        snprintf(out, cap, "%s%llu", x < 0 ? "-" : "", (unsigned long long)n);
}

int jo_gw = JO_W, jo_gh = JO_H;

void jo_px(uint8_t *fb, int x, int y, int v)
{
    uint8_t bit;
    if (x < 0 || x >= jo_gw || y < 0 || y >= jo_gh)
        return;
    bit = (uint8_t)(1u << (y & 7));
    if (v)
        fb[(y >> 3) * jo_gw + x] |= bit;
    else
        fb[(y >> 3) * jo_gw + x] &= (uint8_t)~bit;
}

void jo_xor_px(uint8_t *fb, int x, int y)
{
    if (x >= 0 && x < jo_gw && y >= 0 && y < jo_gh)
        fb[(y >> 3) * jo_gw + x] ^= (uint8_t)(1u << (y & 7));
}

void jo_rect(uint8_t *fb, int x, int y, int w, int h, int v)
{
    for (int j = 0; j < h; j++)
        for (int i = 0; i < w; i++)
            jo_px(fb, x + i, y + j, v);
}

void jo_frame(uint8_t *fb, int x, int y, int w, int h, int v)
{
    jo_rect(fb, x, y, w, 1, v);
    jo_rect(fb, x, y + h - 1, w, 1, v);
    jo_rect(fb, x, y, 1, h, v);
    jo_rect(fb, x + w - 1, y, 1, h, v);
}

void jo_xor_col(uint8_t *fb, int x, int y0, int y1)
{
    for (int y = y0; y <= y1; y++)
        jo_xor_px(fb, x, y);
}

/* the emulator's FONT_SRC, 7 rows of 5 columns, bit 4 = the leftmost column (generated from player.html) */
struct glyph {
    char ch;
    uint8_t rows[7];
};
static const struct glyph FONT[] = {
    {' ', {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}}, {'!', {0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x04}},
    {'#', {0x0a, 0x1f, 0x0a, 0x0a, 0x0a, 0x1f, 0x0a}}, {'%', {0x19, 0x19, 0x02, 0x04, 0x08, 0x13, 0x13}},
    {'*', {0x00, 0x15, 0x0e, 0x1f, 0x0e, 0x15, 0x00}}, {'+', {0x00, 0x04, 0x04, 0x1f, 0x04, 0x04, 0x00}},
    {',', {0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0x08}}, {'-', {0x00, 0x00, 0x00, 0x1f, 0x00, 0x00, 0x00}},
    {'.', {0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0x0c}}, {'/', {0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10}},
    {'0', {0x0e, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0e}}, {'1', {0x04, 0x0c, 0x04, 0x04, 0x04, 0x04, 0x0e}},
    {'2', {0x0e, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1f}}, {'3', {0x0e, 0x11, 0x01, 0x06, 0x01, 0x11, 0x0e}},
    {'4', {0x02, 0x06, 0x0a, 0x12, 0x1f, 0x02, 0x02}}, {'5', {0x1f, 0x10, 0x1e, 0x01, 0x01, 0x11, 0x0e}},
    {'6', {0x06, 0x08, 0x10, 0x1e, 0x11, 0x11, 0x0e}}, {'7', {0x1f, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08}},
    {'8', {0x0e, 0x11, 0x11, 0x0e, 0x11, 0x11, 0x0e}}, {'9', {0x0e, 0x11, 0x11, 0x0f, 0x01, 0x02, 0x0c}},
    {':', {0x00, 0x0c, 0x0c, 0x00, 0x0c, 0x0c, 0x00}}, {'@', {0x0e, 0x11, 0x17, 0x15, 0x17, 0x10, 0x0e}},
    {'A', {0x0e, 0x11, 0x11, 0x1f, 0x11, 0x11, 0x11}}, {'B', {0x1e, 0x11, 0x11, 0x1e, 0x11, 0x11, 0x1e}},
    {'C', {0x0e, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0e}}, {'D', {0x1c, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1c}},
    {'E', {0x1f, 0x10, 0x10, 0x1e, 0x10, 0x10, 0x1f}}, {'F', {0x1f, 0x10, 0x10, 0x1e, 0x10, 0x10, 0x10}},
    {'G', {0x0e, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0f}}, {'H', {0x11, 0x11, 0x11, 0x1f, 0x11, 0x11, 0x11}},
    {'I', {0x0e, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0e}}, {'J', {0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0c}},
    {'K', {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11}}, {'L', {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1f}},
    {'M', {0x11, 0x1b, 0x15, 0x15, 0x11, 0x11, 0x11}}, {'N', {0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11}},
    {'O', {0x0e, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e}}, {'P', {0x1e, 0x11, 0x11, 0x1e, 0x10, 0x10, 0x10}},
    {'Q', {0x0e, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0d}}, {'R', {0x1e, 0x11, 0x11, 0x1e, 0x14, 0x12, 0x11}},
    {'S', {0x0f, 0x10, 0x10, 0x0e, 0x01, 0x01, 0x1e}}, {'T', {0x1f, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}},
    {'U', {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e}}, {'V', {0x11, 0x11, 0x11, 0x11, 0x11, 0x0a, 0x04}},
    {'W', {0x11, 0x11, 0x11, 0x15, 0x15, 0x1b, 0x11}}, {'X', {0x11, 0x11, 0x0a, 0x04, 0x0a, 0x11, 0x11}},
    {'Y', {0x11, 0x11, 0x0a, 0x04, 0x04, 0x04, 0x04}}, {'Z', {0x1f, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1f}},
    {'_', {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1f}}, {'a', {0x00, 0x00, 0x0e, 0x01, 0x0f, 0x11, 0x0f}},
    {'b', {0x10, 0x10, 0x1e, 0x11, 0x11, 0x11, 0x1e}}, {'c', {0x00, 0x00, 0x0e, 0x10, 0x10, 0x11, 0x0e}},
    {'d', {0x01, 0x01, 0x0f, 0x11, 0x11, 0x11, 0x0f}}, {'e', {0x00, 0x00, 0x0e, 0x11, 0x1f, 0x10, 0x0e}},
    {'f', {0x06, 0x09, 0x08, 0x1c, 0x08, 0x08, 0x08}}, {'g', {0x00, 0x0f, 0x11, 0x11, 0x0f, 0x01, 0x0e}},
    {'h', {0x10, 0x10, 0x16, 0x19, 0x11, 0x11, 0x11}}, {'i', {0x04, 0x00, 0x0c, 0x04, 0x04, 0x04, 0x0e}},
    {'j', {0x02, 0x00, 0x06, 0x02, 0x02, 0x12, 0x0c}}, {'k', {0x10, 0x10, 0x12, 0x14, 0x18, 0x14, 0x12}},
    {'l', {0x0c, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0e}}, {'m', {0x00, 0x00, 0x1a, 0x15, 0x15, 0x11, 0x11}},
    {'n', {0x00, 0x00, 0x16, 0x19, 0x11, 0x11, 0x11}}, {'o', {0x00, 0x00, 0x0e, 0x11, 0x11, 0x11, 0x0e}},
    {'p', {0x00, 0x1e, 0x11, 0x11, 0x1e, 0x10, 0x10}}, {'q', {0x00, 0x0f, 0x11, 0x11, 0x0f, 0x01, 0x01}},
    {'r', {0x00, 0x00, 0x16, 0x19, 0x10, 0x10, 0x10}}, {'s', {0x00, 0x00, 0x0f, 0x10, 0x0e, 0x01, 0x1e}},
    {'t', {0x08, 0x08, 0x1c, 0x08, 0x08, 0x09, 0x06}}, {'u', {0x00, 0x00, 0x11, 0x11, 0x11, 0x13, 0x0d}},
    {'v', {0x00, 0x00, 0x11, 0x11, 0x11, 0x0a, 0x04}}, {'w', {0x00, 0x00, 0x11, 0x11, 0x15, 0x15, 0x0a}},
    {'x', {0x00, 0x00, 0x11, 0x0a, 0x04, 0x0a, 0x11}}, {'y', {0x00, 0x11, 0x11, 0x0f, 0x01, 0x01, 0x0e}},
    {'z', {0x00, 0x00, 0x1f, 0x02, 0x04, 0x08, 0x1f}},
};

/* a character the font lacks draws as a space (FONT[ch] || FONT[' ']) but keeps its own width */
static const uint8_t *rows_of(char ch)
{
    for (size_t i = 0; i < sizeof FONT / sizeof FONT[0]; i++)
        if (FONT[i].ch == ch)
            return FONT[i].rows;
    return FONT[0].rows;
}

static int narrow(char ch) { return ch == '.' || ch == ':' || ch == ','; }
static int adv(char ch) { return narrow(ch) ? 3 : ch == ' ' ? 4 : 6; }

int jo_text_w(const char *s, int sc)
{
    int w = 0;
    for (; *s; s++)
        w += adv(*s) * sc;
    return w - sc > 0 ? w - sc : 0;
}

void jo_text(uint8_t *fb, const char *s, int x, int y, int sc, int v)
{
    int cx = x;
    for (; *s; s++) {
        const uint8_t *g = rows_of(*s);
        int off = narrow(*s);
        for (int r = 0; r < 7; r++)
            for (int c = 0; c < 5; c++)
                if (g[r] & (0x10u >> c))
                    jo_rect(fb, cx + (c - off) * sc, y + r * sc, sc, sc, v);
        cx += adv(*s) * sc;
    }
}

void jo_text_r(uint8_t *fb, const char *s, int xr, int y, int sc, int v) { jo_text(fb, s, xr - jo_text_w(s, sc), y, sc, v); }

void jo_text_c(uint8_t *fb, const char *s, int y, int sc, int v)
{
    jo_text(fb, s, jo_iround((double)(jo_gw - jo_text_w(s, sc)) / 2.0), y, sc, v);
}

void jo_icon(uint8_t *fb, const char *const *rows, int n, int x, int y)
{
    for (int j = 0; j < n; j++)
        for (int i = 0; rows[j][i]; i++)
            if (rows[j][i] == '#')
                jo_px(fb, x + i, y + j, 1);
}

/* ---- the ink plane (jo_draw_lcd2) ---- */
static const uint8_t *s_ink_fb;
static uint8_t *s_ink;

void jo_ink_begin(const uint8_t *fb, uint8_t *ink)
{
    s_ink_fb = fb;
    s_ink = ink;
    if (s_ink)
        memset(s_ink, 0, (size_t)jo_gw * (size_t)jo_gh);
}

void jo_ink_end(void)
{
    s_ink_fb = NULL;
    s_ink = NULL;
}

void jo_tag(int id, int x, int y, int w, int h)
{
    if (!s_ink || id == JO_INK_NONE)
        return;
    for (int j = jo_clampi(y, 0, jo_gh); j < jo_clampi(y + h, 0, jo_gh); j++)
        for (int i = jo_clampi(x, 0, jo_gw); i < jo_clampi(x + w, 0, jo_gw); i++)
            if (jo_get(s_ink_fb, i, j))
                s_ink[j * jo_gw + i] = (uint8_t)id;
}

void jo_untag(int x, int y, int w, int h)
{
    if (!s_ink)
        return;
    for (int j = jo_clampi(y, 0, jo_gh); j < jo_clampi(y + h, 0, jo_gh); j++)
        for (int i = jo_clampi(x, 0, jo_gw); i < jo_clampi(x + w, 0, jo_gw); i++)
            s_ink[j * jo_gw + i] = 0;
}

void jo_ink_lit_only(void)
{
    if (!s_ink)
        return;
    for (int j = 0; j < jo_gh; j++)
        for (int i = 0; i < jo_gw; i++)
            if (!jo_get(s_ink_fb, i, j))
                s_ink[j * jo_gw + i] = 0;
}
